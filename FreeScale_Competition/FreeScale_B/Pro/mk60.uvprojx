# Keil uVision project mk60.uvprojx, settings and files
target mk60 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: mk60 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MK60DN512VLQ10
  c misc: --diag_suppress=66
  c include: ..\App\Inc;..\Dev\Inc;..\Drv\Inc;..\Sys\Inc;..\Module\Camera;..\Module\Display;..\Module\Flash;..\Module\Init;..\Module\Scc_Cmt;..\Module\Speed_Control;..\Module\Servo_Control;..\Module\Deal_Data;..\Module\Flash;..\Module\Angle_Calculation;..\Module\ManDarin;..\Module\module_2401;..\Module\Meeting_Car
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\Dev\Src\MK60DN512xxx10_flash.scf
  group App
    ../App/Src/: main.c board.c clock_config.c pin_mux.c
    ../App/Inc/: include.h pin_mux.h
  group Init
    ../Module/Init/: init.c init.h
  group Servo_Control
    ../Module/Servo_Control/: Servo_Control.c Servo_Control.h
  group Deal_Data
    ../Module/Deal_Data/: Deal_image.c Deal_image.h Deal_elec.c Deal_elec.h
  group Speed_Control
    ../Module/Speed_Control/: Speed_Control.c Speed_Control.h
  group Meeting_Car
    ../Module/Meeting_Car/: Meeting_Car.c Meeting_Car.h
  group Display
    ../Module/Display/: disply_send.c disply_send.h LED.c LED.h Data_Transfer.c data_transfer.h OSC.c OSC.h
  group Transmission
    ../Module/module_2401/: 24L01_f.c 24L01_f.h 24L01_s.c 24L01_s.h
  group Camera
    ../Module/Camera/: camera.c camera.h OV7725_REG.h SCCB.c SCCB.h
  group Angle_Calculation
    ../Module/Angle_Calculation/: 6050_i2c.c 6050_i2c.h user_i2c.c user_i2c.h
  group manDarin
    ../Module/ManDarin/: mandarin.c mandarin.h
  group Flash
    ../Module/Flash/: flash.c flash.h
  group Scc_cmt
    ../Module/Scc_Cmt/: SCC_CMT.c SCC_CMT.h
  group Sys
    ../Dev/Src/: system_MK60D10.c
    ../Dev/Inc/: system_MK60D10.h MK60D10.h MK60D10_features.h
    ../Drv/Src/: fsl_common.c
    ../Drv/Inc/: fsl_common.h
  group Dev
    ../Dev/Src/: startup_MK60D10.s fsl_debug_console.c
    ../Dev/Inc/: fsl_debug_console.h
  group Dry
    ../Drv/Src/: fsl_adc16.c fsl_clock.c fsl_flash.c fsl_ftm.c fsl_gpio.c fsl_i2c.c fsl_pit.c fsl_uart.c fsl_edma.c
    ../Drv/Inc/: fsl_adc16.h fsl_clock.h fsl_flash.h fsl_ftm.h fsl_gpio.h fsl_port.h fsl_i2c.h fsl_pit.h fsl_uart.h fsl_edma.h
  group TXT
    ../Module/TXT/: read.txt
